options:
  parameters:
    author: Rafael Ferreira
    copyright: UIS
    generate_options: qt_gui
    id: modeladora_de_amplitud
    output_language: python
    title: modulador_AM_GNURADIO
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portafora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.250'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia tx
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente de sensibilidad AM
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '195312'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: moduladorAM_lab3_parteA_0
  id: moduladorAM_lab3_parteA
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"green"'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', moduladorAM_lab3_parteA_0, '0']
- [blocks_complex_to_real_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [moduladorAM_lab3_parteA_0, '0', blocks_complex_to_real_0, '0']
- [moduladorAM_lab3_parteA_0, '0', qtgui_freq_sink_x_0, '0']
- [moduladorAM_lab3_parteA_0, '0', qtgui_time_sink_x_0, '0']
- [moduladorAM_lab3_parteA_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
