options:
  parameters:
    author: Ferreira_Barreto
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: ModuladorAM_GNURadio_C1A_G6
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuancia mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: k_a
  id: variable_qtgui_range
  parameters:
    label: coeficiente de sensibilidad
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/64
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: LAB3_parteA_G6_0
  id: LAB3_parteA_G6
  parameters:
    Ac: '1'
    ka: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: Envolvente compleja
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Envolvente compleja
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [LAB3_parteA_G6_0, '0', blocks_complex_to_real_0, '0']
- [LAB3_parteA_G6_0, '0', qtgui_freq_sink_x_0, '0']
- [LAB3_parteA_G6_0, '0', qtgui_time_sink_x_0, '0']
- [LAB3_parteA_G6_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', LAB3_parteA_G6_0, '0']
- [blocks_complex_to_real_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
